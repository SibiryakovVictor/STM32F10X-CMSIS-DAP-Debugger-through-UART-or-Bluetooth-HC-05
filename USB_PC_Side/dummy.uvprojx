# Keil uVision project dummy.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy +hex
  BeforeMake: .\src\retarget\update_commit_hash.bat
  AfterMake: .\src\retarget\remove_commit_hash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB, SYSCLK_FREQ_HSE
  c misc: --feedback=unused
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\main;.\src\hal;.\src\usb
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --feedback=unused
  group common_functions
    ./src/common_functions/: common_functions.cpp common_functions.h
  group main
    ./src/main/: main.c DAP.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c usb_device.c usbd_conf.c usbd_dap_cdc.c usbd_dap_cdc_if.c usbd_desc.c bluetooth_AT.c bluetooth_AT.h
  group mcu_support_package
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
    ./src/mcu_support_package/: system_stm32f10x.c
  group retarget
    ./src/retarget/: retarget.cpp
  group usb
    ./src/usb/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group hal
    ./src/hal/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
software components: CMSIS:CORE 5.0.1
